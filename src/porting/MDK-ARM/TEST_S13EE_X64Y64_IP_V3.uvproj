# Keil uVision project TEST_S13EE_X64Y64_IP_V3.uvproj, settings and files
target TEST_S13EE_X64Y64_IP_V3 (ARM-ADS)
  device: STM32F407ZE STMicroelectronics
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: TEST_S13EE_X64Y64_IP_V3 +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx
  c include: ..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\USER;..\Libraries\CMSIS\Include;..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\Libraries\CMSIS;..\BSP
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group StartUp
    ./: startup_stm32f4xx.s
  group USER
    ../USER/: bsp_printf.c datarom.c eeprom.c main.c RA8875.c stm32f4xx_it.c system_stm32f4xx.c
  group StdPeriph_Driver
    ../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_usart.c stm32f4xx_wwdg.c stm32f4xx_tim.c
  group BSP
    ../BSP/: LED.C pwm.c SysTick.C usart1.c common.c bsp.c
